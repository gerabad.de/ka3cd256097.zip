Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_44_Nnf4p/format_1/3255(architecture=300).ifc
Time: 2025-09-01T09:05:50
Made in: PARTsolutions

# IfcProject, 3255(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3255(architecture=300)
In: BUILDING
Description: 3255(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3255
ePset_PARTsolutions - NB: 3255(architecture=300); NN: 3255; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3255(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3255; B: 3255_aluvia_1000x1000.png; C: ALUVIA; E: KALDEWEI; EF000049: 1000; EF004567: 1000; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1000; etim7_EC003246_LENGTH: 1000
